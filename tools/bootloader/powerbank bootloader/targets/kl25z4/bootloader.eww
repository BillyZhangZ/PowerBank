<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar\freedom_msd\freedom_msd_bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar\tower_bootloader\tower_bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar\freedom_bootloader\freedom_bootloader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All configurations</name>
      <member>
        <project>tower_bootloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tower_bootloader</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>freedom_bootloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freedom_bootloader</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>freedom_msd_bootloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freedom_msd_bootloader</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


