# IAR project freedom_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREEDOM; CPU_MKL25Z128VLK4; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\autobaud; ..\..\..\..\src\drivers; ..\..\..\..\src\startup; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\usb_device\driver; ..\..\..\..\src\usb_device\driver\kinetis; ..\..\..\..\src\usb_device\common; ..\..\..\..\src\usb_device\class; ..\..\..\..\src\usb_device\hid; ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_TARGET_FLASH
  AARM.AUserIncludes: ..\..\..\..\src\include
  OBJCOPY.OOCOutputFile: freedom_bootloader.srec
  ILINK.IlinkOutputFile: freedom_bootloader.elf
  ILINK.IlinkIcfFile: E:\Codes Repository\FSL_Kinetis_Bootloader_1_0_1\FSL_Kinetis_Bootloader_1_0_1\targets\common\iar\config\128KB_Pflash_16KB_RAM_low_bootloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FREEDOM; CPU_MKL25Z128VLK4; NDEBUG; BL_TARGET_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\autobaud; ..\..\..\..\src\drivers; ..\..\..\..\src\common; ..\..\..\..\src\startup; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\platforms; ..\..\..\..\src\usb_device\driver; ..\..\..\..\src\usb_device\driver\kinetis; ..\..\..\..\src\usb_device\common; ..\..\..\..\src\usb_device\class; ..\..\..\..\src\usb_device\hid; ..\..\src; E:\Freescale Referrence Designs\20140905 Power Bank Project\Source Code Tree\PowerBank\tools\bootloader\powerbank bootloader\src\led
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BL_TARGET_FLASH
  ILINK.IlinkIcfFile: ..\..\..\common\iar\config\128KB_Pflash_16KB_RAM_low_bootloader.icf
  group kl25z4
    ../../src/: bootloader_config.h clock_config_MKL25Z4.c hardware_init_MKL25Z4.c memory_map_MKL25Z4.c peripherals_MKL25Z4.c
  group link
    ../../../common/iar/config/: 128KB_Pflash_16KB_RAM_low_bootloader.icf
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h command.h context.h init_info.h peripheral.h shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bl_user_entry.c bootloader.c bootloader_context.c bootloader_tree_root.c command.c i2c_peripheral_interface.c shutdown_cleanup.c spi_peripheral_interface.c uart0_peripheral_interface.c usb_hid_peripheral_interface.c
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/drivers/flash
    ../../../../src/drivers/flash/: flash.h
    ../../../../src/drivers/flash/src/: flash_command_sequence.c flash_densities_kl_series.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_protected.c flash_program.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c SSD_FTFx_Common.h
  group src/drivers/i2c
    ../../../../src/drivers/i2c/: fsl_i2c_slave_driver.h
  group src/drivers/i2c/src
    ../../../../src/drivers/i2c/src/: fsl_i2c_slave_driver.c
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/spi
    ../../../../src/drivers/spi/: fsl_spi_slave_driver.h fsl_spi_types.h
  group src/drivers/spi/hal
    ../../../../src/drivers/spi/hal/: fsl_spi_features.h fsl_spi_hal.c fsl_spi_hal.h
  group src/drivers/spi/src
    ../../../../src/drivers/spi/src/: fsl_spi_slave_driver.c
  group src/drivers/uart
    ../../../../src/drivers/uart/: uart.c uart.h uart0.c uart0.h
  group src/include
    ../../../../src/include/: bootloader_common.h fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/led
    ../../../../src/led/: led.c led.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: device_memory.c device_memory.h flash_memory.c memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init_cm0plus.c
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: chunking_gasket.h itf_define.h itf_rom.h ldr_config.h loader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: chunking_gasket.c itf_rom.c loader.c
  group src/startup
    ../../../../src/startup/: boot.s crt0.s startup.c
    ../../../../src/startup/MKL25Z4/: startup_MKL25Z4.s system_MKL25Z4.c
  group src/usb_device
    ../../../../src/usb_device/: bootloader_hid_report_ids.h
  group src/usb_device/class
    ../../../../src/usb_device/class/: usb_hid.c usb_hid.h
  group src/usb_device/common
    ../../../../src/usb_device/common/: derivative.h hidef.h usb_class.c usb_class.h usb_framework.c usb_framework.h usb_types.h wdt_kinetis.h
  group src/usb_device/driver
    ../../../../src/usb_device/driver/kinetis/: usb_bdt_kinetis.h usb_dci_kinetis.c usb_dci_kinetis.h usb_dciapi.h
    ../../../../src/usb_device/driver/: usb_devapi.h usb_driver.c usbevent.c usbevent.h
  group src/usb_device/hid
    ../../../../src/usb_device/hid/: USB_Config.h usb_descriptor.c usb_descriptor.h user_config.h
  group src/utilities
    ../../../../src/utilities/src/: fsl_rtos_abstraction.c ring_buffer.c
    ../../../../src/utilities/: fsl_rtos_abstraction.h ring_buffer.h vector_table_info.h
