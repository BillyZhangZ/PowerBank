<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>kl25z4</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\bootloader_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\clock_config_MKL25Z4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\hardware_init_MKL25Z4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\memory_map_MKL25Z4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\peripherals_MKL25Z4.c</name>
    </file>
  </group>
  <group>
    <name>link</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\common\iar\config\128KB_Pflash_16KB_RAM_low_bootloader.icf</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <group>
      <name>autobaud</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\autobaud\src\autobaud_irq.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\autobaud\autobaud.h</name>
      </file>
    </group>
    <group>
      <name>bootloader</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bl_user_entry.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader_context.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\bootloader_tree_root.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\command.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\i2c_peripheral_interface.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\shutdown_cleanup.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\spi_peripheral_interface.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\uart0_peripheral_interface.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\bootloader\src\usb_hid_peripheral_interface.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bl_peripheral_interface.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bl_user_entry.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bl_version.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\bootloader.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\command.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\context.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\init_info.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\peripheral.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\bootloader\shutdown_cleanup.h</name>
      </file>
    </group>
    <group>
      <name>crc</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\crc\src\crc16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\crc\src\crc32.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\crc\crc16.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\crc\crc32.h</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_command_sequence.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_densities_kl_series.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_erase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_erase_all.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_erase_all_unsecure.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_get_property.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_get_security_state.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_is_protected.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_program.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_security_bypass.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_verify_erase.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_verify_erase_all.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\flash_verify_program.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\flash\src\SSD_FTFx_Common.h</name>
        </file>
      </group>
      <group>
        <name>i2c</name>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\i2c\src\fsl_i2c_slave_driver.c</name>
          </file>
        </group>
        <group>
          <name>test</name>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\i2c\fsl_i2c_slave_driver.h</name>
        </file>
      </group>
      <group>
        <name>microseconds</name>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\microseconds\src\microseconds_sysclk.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\microseconds\microseconds.h</name>
        </file>
      </group>
      <group>
        <name>spi</name>
        <group>
          <name>hal</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\spi\hal\fsl_spi_features.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\spi\hal\fsl_spi_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\spi\hal\fsl_spi_hal.h</name>
          </file>
        </group>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\src\drivers\spi\src\fsl_spi_slave_driver.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\spi\fsl_spi_slave_driver.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\spi\fsl_spi_types.h</name>
        </file>
      </group>
      <group>
        <name>uart</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\uart\uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\uart\uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\uart\uart0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\drivers\uart\uart0.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\bootloader_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\fsl_platform_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\fsl_platform_status.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\include\fsl_platform_types.h</name>
      </file>
    </group>
    <group>
      <name>memory</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\device_memory.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\device_memory.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\flash_memory.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\memory.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\normal_memory.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\normal_memory.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\pattern_fill.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\pattern_fill.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\memory\src\sram_init_cm0plus.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\memory\memory.h</name>
      </file>
    </group>
    <group>
      <name>packet</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\packet\src\serial_packet.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\packet\command_packet.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\packet\serial_packet.h</name>
      </file>
    </group>
    <group>
      <name>property</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\property\src\property.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\property\property.h</name>
      </file>
    </group>
    <group>
      <name>sbloader</name>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\sbloader\src\chunking_gasket.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\sbloader\src\itf_rom.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\sbloader\src\loader.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\sbloader\chunking_gasket.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\sbloader\itf_define.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\sbloader\itf_rom.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\sbloader\ldr_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\sbloader\loader.h</name>
      </file>
    </group>
    <group>
      <name>startup</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\boot.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\startup.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\MKL25Z4\startup_MKL25Z4.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\startup\MKL25Z4\system_MKL25Z4.c</name>
      </file>
    </group>
    <group>
      <name>usb_device</name>
      <group>
        <name>class</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\class\usb_hid.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\class\usb_hid.h</name>
        </file>
      </group>
      <group>
        <name>common</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\derivative.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\hidef.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\usb_class.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\usb_class.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\usb_framework.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\usb_framework.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\usb_types.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\common\wdt_kinetis.h</name>
        </file>
      </group>
      <group>
        <name>driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\kinetis\usb_bdt_kinetis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\kinetis\usb_dci_kinetis.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\kinetis\usb_dci_kinetis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\kinetis\usb_dciapi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\usb_devapi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\usb_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\usbevent.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\driver\usbevent.h</name>
        </file>
      </group>
      <group>
        <name>hid</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\hid\USB_Config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\hid\usb_descriptor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\hid\usb_descriptor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\src\usb_device\hid\user_config.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\usb_device\bootloader_hid_report_ids.h</name>
      </file>
    </group>
    <group>
      <name>utilities</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\src\fsl_rtos_abstraction.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\fsl_rtos_abstraction.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\src\ring_buffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\ring_buffer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\src\utilities\vector_table_info.h</name>
      </file>
    </group>
  </group>
</project>


